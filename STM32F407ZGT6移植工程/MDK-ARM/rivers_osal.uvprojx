# Keil uVision project rivers_osal.uvprojx, settings and files
target rivers_osal (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: rivers_osal +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../middleware/RTT;../middleware/osal/Inc;../Middleware/osal/system/Inc;../Middleware/osal/components/periph/usart/Inc;../Middleware/osal/components/periph/flash/Inc;../Middleware/osal/platform/stm32f4;..\Middleware\osal\platform\example\stm32f4
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dma.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_uart.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middleware/osal/system
    ../Middleware/osal/system/Src/: osal_event.c osal_irq.c osal_mem.c osal_mutex.c osal_queue.c osal_task.c osal_timer.c
  group Middleware/osal/components
    ../Middleware/osal/components/periph/usart/Src/: periph_uart.c
    ../Middleware/osal/components/periph/flash/Src/: periph_flash.c
  group Middleware/rtt
    ../middleware/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c SEGGER_RTT_FORMATTER.h
  group Middleware/osal/platform
    ../Middleware/osal/platform/example/stm32f4/: osal_platform_stm32f4.c osal_platform_stm32f4.h
software components: CMSIS:CORE 4.3.0
